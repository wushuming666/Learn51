# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\catch;.\App;.\Public;.\User;.\App\show;.\App\change;.\App\sound;.\App\wifi
  group App
    ./App/catch/: ds18b20.c catch.c
    ./App/show/: lcd1602.c
    ./App/sound/: sound.c
    ./App/change/: change.c
    ./App/wifi/: wifi.c
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c uart.c
